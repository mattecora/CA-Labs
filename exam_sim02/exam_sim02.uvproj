# Keil uVision project exam_sim02.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: exam_sim02
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group joystick
    ./joystick/: func_joystick.c lib_joystick.c
  group led
    ./led/: func_led.c lib_led.c
  group main
    ./main/: main.c
  group overflow
    ./overflow/: overflow.s overflow.h
  group rit
    ./rit/: IRQ_rit.c lib_rit.c
  group system
    ./system/: system_LPC17xx.c startup_LPC17xx.s
  group timer
    ./timer/: IRQ_timer.c lib_timer.c
